File: boost_converter.kicad_sch (KiCad schematic)
At the start: 12 parts, among them U6 MP3423

Commit message: update to kicad 9.0
