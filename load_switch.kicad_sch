File: load_switch.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U2 XC6192B

Commit message: update to kicad 9.0
